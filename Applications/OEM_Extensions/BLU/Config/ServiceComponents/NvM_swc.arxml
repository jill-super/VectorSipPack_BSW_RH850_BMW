<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="1fd18170-d612-44ba-8b8c-122100db02ae">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="a41ff949-0e71-4652-8b74-36e4c4dc6db2">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="f14eb973-b762-4bf5-b421-7d5a3f81bee0">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="132e458b-a49d-4a5c-bdc8-3061176079c0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0d8d9ff8-9bf7-46f7-9e6a-8ba7767c327d">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="34d7b447-cadc-4935-9316-64e92b31dca6">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c285f726-dcb9-4b99-bb7e-9e7b3cf8870e">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
