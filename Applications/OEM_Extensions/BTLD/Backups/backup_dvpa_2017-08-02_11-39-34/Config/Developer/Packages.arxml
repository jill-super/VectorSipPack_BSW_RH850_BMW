<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="39B2DDB1-D68D-4553-8D7C-9FB17DF591BC">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4EC0BAFD-171B-4AF1-A1D1-068581401FB1">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2A183149-3ECE-401C-8AFD-7B5D9A499DC5">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="68F8A5BC-1F5E-4BF3-B698-8F22EB15D718">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FFB7460A-E8E3-4F11-84A9-2A5128EFDC3B">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="81307993-D540-469B-9D6D-EFB04C4950E2">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="346E3CFF-55AC-4D75-B4C4-22DE66E261D3">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="084495EB-67C0-4243-A493-3849E00F411E">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3C60B668-CFEC-4480-A89B-9FFD7287FF7E">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5A5E7BA8-DB99-41EA-A5CB-739D24BE9CE9">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="21CF8FD4-AE7F-42FF-8ABB-B97C33CF9BF1">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="987DB7B5-915E-4634-B273-935BCBC1CCDD">
              <SHORT-NAME>CommunicationClusters</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A01A5F12-7145-4A50-ABF8-0D54F0DE62C9">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="160B9A39-39A3-46DD-B556-24A2A0EE4897">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C86B01E4-494D-4A2C-9C8A-FDD624BADACB">
              <SHORT-NAME>EcuInstances</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="02AB6D63-31A8-4245-B737-D7947C36192B">
              <SHORT-NAME>EndtoEndProtections</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2DC6100F-8E87-4BC9-BA82-E992CCC24916">
              <SHORT-NAME>Frames</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C6428EDA-9406-4307-AB10-C3FF11928900">
              <SHORT-NAME>ISignalGroups</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="73AD821D-A609-43F9-9B24-EAE9BDC55037">
              <SHORT-NAME>ISignalIPduGroups</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A2647873-9C73-4ADD-A2A5-34A31E1D2C54">
              <SHORT-NAME>ISignals</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="48D937F3-43DD-4B02-AA61-9863C76025C9">
              <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="BC3F0C19-1E93-4F1C-9421-0A85F84C131C">
                  <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BF83522C-F5DB-4BE8-8A26-263004538608">
                  <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A455F9CF-9BE6-4789-B854-303AC86B4FA4">
              <SHORT-NAME>Pdus</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2D2FDBE5-F9B0-4A62-B9D4-4C497E3038AE">
              <SHORT-NAME>Systems</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4BC08830-EC49-4E40-AF6F-F0C7E3E691B7">
              <SHORT-NAME>SystemSignalGroups</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="275A02B9-6CAA-4494-9703-3D70027B12B2">
              <SHORT-NAME>SystemSignals</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="A020BFE2-51F5-4801-993A-4B350F2C04C8">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7D55E9A1-C072-4CE3-B08D-5E9DB45792D6">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A0D4D980-DC0F-47A4-95F3-EE30C156B20E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="53AD6076-611E-4F5A-B4EC-DB4556253F7F">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9624E821-A653-4F21-883C-40335BA7C532">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B045BCC7-9616-4576-A5BD-05B650314316">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4B53270E-B71B-4CA9-B13C-E5162472E050">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="29878E00-F1A5-4DA9-B0BC-3B53735BD632">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2626F065-1BF2-4D5F-9AD3-8233E579BA02">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="745D8F54-D88D-4493-AED2-4EAF19AE4940">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5E4160F5-E6A7-4E43-9F19-BA07795A3C0B">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="32CA1774-90F9-465F-9504-FB4765260810">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="00D34D35-20B4-4689-82A5-314C3E084875">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1fd18170-d612-44ba-8b8c-122100db02ae">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="f56eda74-796d-47bc-a0fc-333282b941a5">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="94e038be-e9a7-4dbd-b59b-75dc63877f18">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="f0ae6db0-bd1d-44d9-9563-19db47423842">
          <SHORT-NAME>ComM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="37b23c0a-f1ce-4d0c-9634-aa084e3d677d">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3e9199dd-18cc-49a8-b9db-f2138672999c">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="b1584fd9-c612-4fc0-9dfa-c7c5c382586a">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="f87e3bc7-e361-465a-a884-d9ee875dbe48">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="f172f6dc-fb64-4d5a-9b91-9a2967c5f447">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0f04aa2b-ec41-40a3-afb3-d180fa237246">
          <SHORT-NAME>Det_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6371ddb5-9339-43ec-b12c-93854f5cd011">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="573a22cd-90c3-4155-8bbd-3cccaf235c01">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="c8c9dc31-4767-4e1d-970a-931a7d74946e">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="29d19ade-cd1d-43f2-9e5c-0353d26e5a0c">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="f7d2da18-f8a7-4c06-8440-3649d0f99f0c">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="1cec2f0a-110a-4cc9-8ef7-c853819f348e">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="e441fb69-fdb5-4efb-a8c9-5c1eacffd2e3">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0be63afe-3597-4dff-8d8f-ded978c5c21a">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4a0c188d-6474-47da-a5d8-350ad57bc88f">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="35d85c0b-a57f-4a63-919e-3c66987dd424">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="72ed78db-4159-4125-9bfe-3ee11e4ab21d">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="53f03629-0de4-4614-941a-d5bb294cfbfb">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C80A7732-BD74-44E7-9FB8-92FCDDC9BE01">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0F1A6FFA-9052-47FE-9A65-A774A1C57685">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9322043D-0FB7-4DFB-904D-FC9AB1A93FEA">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B4295A52-DA91-44D7-908E-A5F59051E872">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="70BE3148-DC78-4D4F-A597-47F3620C57FB">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A1E8BD5D-3C45-46FE-AEFA-A9239303DDB1">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D481D2D8-2596-4CE9-875A-664DCA86FAA4">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8F82549F-4FF5-4911-B018-1CFE86A95B84">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>