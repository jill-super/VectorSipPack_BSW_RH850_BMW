<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="39B2DDB1-D68D-4553-8D7C-9FB17DF591BC">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4EC0BAFD-171B-4AF1-A1D1-068581401FB1">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2A183149-3ECE-401C-8AFD-7B5D9A499DC5">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="68F8A5BC-1F5E-4BF3-B698-8F22EB15D718">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FFB7460A-E8E3-4F11-84A9-2A5128EFDC3B">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="81307993-D540-469B-9D6D-EFB04C4950E2">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="346E3CFF-55AC-4D75-B4C4-22DE66E261D3">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="084495EB-67C0-4243-A493-3849E00F411E">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D7A5C40C-0940-47FD-9EFC-4931DD8BA042">
      <SHORT-NAME>BMW</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="6626856D-B198-403A-8991-CF8721807E6E">
          <SHORT-NAME>SystemDescription</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="8F10B5EA-E2D9-433C-BF9A-E2C45D67815F">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="23228379-00FB-4EBB-91B2-3425DA90E291">
              <SHORT-NAME>CommunicationClusters</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0D775A70-C3D9-40E7-A313-C827AEECAB2E">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="F90246D7-E545-4324-8177-57B5E06AB902">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8D10157A-2C50-465B-A39F-4C704C9E8C79">
              <SHORT-NAME>EcuInstances</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="88EF0E6F-0037-456A-96D1-934C0C92E98D">
              <SHORT-NAME>EndtoEndProtections</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="038848C9-7170-4835-B232-7F058886A1A3">
              <SHORT-NAME>Frames</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8359FFD6-7B41-4ABB-B020-A17EE0FD9515">
              <SHORT-NAME>ISignalGroups</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0D76315A-3A78-4295-95BD-7C3EA6DB247D">
              <SHORT-NAME>ISignalIPduGroups</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="38C280D7-054B-4898-A1B8-7D793E41719D">
              <SHORT-NAME>ISignals</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C1E0F10C-2130-471C-9F54-559F583CD544">
              <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="DD34A16D-27F0-40BB-8EA2-8EA1201DD400">
                  <SHORT-NAME>BasePartialNetworks</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8690FF69-4635-4C29-A35C-F09BBE7ADDD7">
                  <SHORT-NAME>FunctionalPartialNetworks</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="98ED8010-F08A-41C2-8CB6-AF23072671F0">
              <SHORT-NAME>Pdus</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7E5CD501-BB4C-4A1F-8810-D7C1F1C3C75C">
              <SHORT-NAME>Systems</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="F5CA23F7-2921-4360-AFC1-40AC183D0481">
              <SHORT-NAME>SystemSignalGroups</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C649702B-D42C-4AD3-9380-67FCFE37E9AD">
              <SHORT-NAME>SystemSignals</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="AA45FFA1-788E-445A-A1EF-57313963BCAB">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7D55E9A1-C072-4CE3-B08D-5E9DB45792D6">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A0D4D980-DC0F-47A4-95F3-EE30C156B20E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="53AD6076-611E-4F5A-B4EC-DB4556253F7F">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9624E821-A653-4F21-883C-40335BA7C532">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B045BCC7-9616-4576-A5BD-05B650314316">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4B53270E-B71B-4CA9-B13C-E5162472E050">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="29878E00-F1A5-4DA9-B0BC-3B53735BD632">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2626F065-1BF2-4D5F-9AD3-8233E579BA02">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="745D8F54-D88D-4493-AED2-4EAF19AE4940">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5E4160F5-E6A7-4E43-9F19-BA07795A3C0B">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="32CA1774-90F9-465F-9504-FB4765260810">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="00D34D35-20B4-4689-82A5-314C3E084875">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1fd18170-d612-44ba-8b8c-122100db02ae">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="f56eda74-796d-47bc-a0fc-333282b941a5">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="94e038be-e9a7-4dbd-b59b-75dc63877f18">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="f0ae6db0-bd1d-44d9-9563-19db47423842">
          <SHORT-NAME>ComM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="37b23c0a-f1ce-4d0c-9634-aa084e3d677d">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3e9199dd-18cc-49a8-b9db-f2138672999c">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="b1584fd9-c612-4fc0-9dfa-c7c5c382586a">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="f87e3bc7-e361-465a-a884-d9ee875dbe48">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="f172f6dc-fb64-4d5a-9b91-9a2967c5f447">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="26870477-a895-42d5-aede-5c72197a5b39">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="fb27aef5-6f80-41c8-a190-5da5b8100315">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="aa8f7116-0437-4be6-b264-c9ef711b32e0">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="7682d2a3-7458-44c3-a774-1c942f8c5706">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="ac71fc1e-994b-4349-94cc-1fb845aa2b46">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="83102b07-0d74-45ff-8593-cd75bd3c2d71">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0f04aa2b-ec41-40a3-afb3-d180fa237246">
          <SHORT-NAME>Det_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6371ddb5-9339-43ec-b12c-93854f5cd011">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="573a22cd-90c3-4155-8bbd-3cccaf235c01">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="c8c9dc31-4767-4e1d-970a-931a7d74946e">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="29d19ade-cd1d-43f2-9e5c-0353d26e5a0c">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="f7d2da18-f8a7-4c06-8440-3649d0f99f0c">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="1cec2f0a-110a-4cc9-8ef7-c853819f348e">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="e441fb69-fdb5-4efb-a8c9-5c1eacffd2e3">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0be63afe-3597-4dff-8d8f-ded978c5c21a">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4a0c188d-6474-47da-a5d8-350ad57bc88f">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="0b762402-acf3-4179-9ec7-0e932cde50a7">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="35d85c0b-a57f-4a63-919e-3c66987dd424">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="72ed78db-4159-4125-9bfe-3ee11e4ab21d">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="53f03629-0de4-4614-941a-d5bb294cfbfb">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C80A7732-BD74-44E7-9FB8-92FCDDC9BE01">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0F1A6FFA-9052-47FE-9A65-A774A1C57685">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9322043D-0FB7-4DFB-904D-FC9AB1A93FEA">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B4295A52-DA91-44D7-908E-A5F59051E872">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="70BE3148-DC78-4D4F-A597-47F3620C57FB">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A1E8BD5D-3C45-46FE-AEFA-A9239303DDB1">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D481D2D8-2596-4CE9-875A-664DCA86FAA4">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8F82549F-4FF5-4911-B018-1CFE86A95B84">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>